# IAR project zqstm32f207vet6A.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207VE ST STM32F207VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _APP_; STM32F2XX; USE_STDPERIPH_DRIVER; APP_Address=((uint32_t)0x08008000)
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\Libraries\CMSIS\Device\ST\STM32F2xx\Include; ..\Libraries\CMSIS\Include; ..\User; ..\User\lua\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: zqstm32f207vet6A.hex
  ILINK.IlinkOutputFile: zqstm32f207vet6A.out
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group Doc
    ../Doc/: log.txt
  group FWlib
    ../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_usart.c
  group StartUp
    ../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/iar/: startup_stm32f2xx.s
    ../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group User
    ../User/: dbg.c main.c
    ../User/nvic/: nvic.c
    ../User/st_debug/: st_debug.c
