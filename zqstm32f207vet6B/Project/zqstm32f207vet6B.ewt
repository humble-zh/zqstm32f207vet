<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Doc</name>
  </group>
  <group>
    <name>FWlib</name>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_usart.c</name>
    </file>
  </group>
  <group>
    <name>Lwip-1.3.2</name>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\api\api_lib.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\api\api_msg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\core\ipv4\autoip.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\core\dhcp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\core\dns.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\api\err.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\netif\etharp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\core\ipv4\icmp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\core\ipv4\igmp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\core\ipv4\inet.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\core\ipv4\inet_chksum.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\core\init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\core\ipv4\ip.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\core\ipv4\ip_addr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\core\ipv4\ip_frag.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\core\mem.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\core\memp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\api\netbuf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\api\netdb.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\core\netif.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\api\netifapi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\core\pbuf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\core\raw.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\api\sockets.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\core\stats.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\core\sys.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\core\tcp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\core\tcp_in.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\core\tcp_out.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\api\tcpip.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\lwip-1.3.2\src\core\udp.c</name>
    </file>
  </group>
  <group>
    <name>StartUp</name>
    <file>
      <name>$PROJ_DIR$\..\Libraries\CMSIS\Device\ST\STM32F2xx\Source\Templates\iar\startup_stm32f2xx.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\CMSIS\Device\ST\STM32F2xx\Source\Templates\system_stm32f2xx.c</name>
    </file>
  </group>
  <group>
    <name>STM32F2x7_ETH_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2x7_ETH_Driver\src\stm32f2x7_eth.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <group>
      <name>Cmd</name>
      <file>
        <name>$PROJ_DIR$\..\User\shell\cmd\echo\echo.c</name>
      </file>
    </group>
    <group>
      <name>Fgetopt</name>
      <file>
        <name>$PROJ_DIR$\..\User\shell\fgetopt\fgetopt.c</name>
      </file>
    </group>
    <group>
      <name>tcptest</name>
      <file>
        <name>$PROJ_DIR$\..\User\tcptest\tcptest.c</name>
      </file>
    </group>
    <group>
      <name>udptest</name>
      <file>
        <name>$PROJ_DIR$\..\User\udptest\udptest.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\User\dbg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\lwipport\STM32F2x7\Standalone\ethernetif.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\netconf\netconf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\nvic\nvic.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\shell\shell.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\st_debug\st_debug.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\systimer\systimer.c</name>
    </file>
  </group>
</project>


