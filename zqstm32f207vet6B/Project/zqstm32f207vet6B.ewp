# IAR project zqstm32f207vet6B.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207VE ST STM32F207VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F2XX; USE_STDPERIPH_DRIVER; APP_Address=((uint32_t)0x08008000)
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\Libraries\CMSIS\Device\ST\STM32F2xx\Include; ..\Libraries\CMSIS\Include; ..\Libraries\STM32F2x7_ETH_Driver\inc; ..\User; ..\User\shell; ..\User\lwipport\STM32F2x7; ..\User\lwipport\STM32F2x7\Standalone; ..\lwip-1.3.2\src\include; ..\lwip-1.3.2\src\include\ipv4; ..\lwip-1.3.2\src\include\netif
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: zqstm32f207vet6B.hex
  ILINK.IlinkOutputFile: zqstm32f207vet6B.out
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group FWlib
    ../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_syscfg.c stm32f2xx_usart.c
  group Lwip-1.3.2
    ../lwip-1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../lwip-1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../lwip-1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../lwip-1.3.2/src/netif/: etharp.c
  group StartUp
    ../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/iar/: startup_stm32f2xx.s
    ../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group STM32F2x7_ETH_Driver
    ../Libraries/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
  group User
    ../User/: dbg.c main.c
    ../User/lwipport/STM32F2x7/Standalone/: ethernetif.c
    ../User/netconf/: netconf.c
    ../User/nvic/: nvic.c
    ../User/shell/: shell.c
    ../User/st_debug/: st_debug.c
    ../User/systimer/: systimer.c
  group User/Cmd
    ../User/shell/cmd/echo/: echo.c
  group User/Fgetopt
    ../User/shell/fgetopt/: fgetopt.c
