<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\zqstm32f207vet6B.ewp</path>
  </project>
  <batchBuild/>
</workspace>


